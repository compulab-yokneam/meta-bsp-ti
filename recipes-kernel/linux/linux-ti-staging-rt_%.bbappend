require recipes-kernel/linux/linux-ti-staging-cm-t43.inc
